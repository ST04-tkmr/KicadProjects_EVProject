# Repository ST04-tkmr/KicadProjects_EVProject

## KiCad design ECUShield_MEGA_ver1/ECUShield_MEGA_ver1.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1u; C_0603_1608Metric
D1: NUP2105L; SOT-23
D2, D3, D4: 1S953; D_DO-35_SOD27_P7.62mm_Horizontal
J1: Conn_02x03_Odd_Even; PinSocket_2x03_P2.54mm_Vertical
J2, J3, J13, J14, J15, J16, J17, J18, J19, J20, J21: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4, J5, J6: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J7: Power; PinSocket_1x08_P2.54mm_Vertical
J8, J9: Analog; PinSocket_1x08_P2.54mm_Vertical
J10: PWM; PinSocket_1x10_P2.54mm_Vertical
J11: PWM; PinSocket_1x08_P2.54mm_Vertical
J12: Communication; PinSocket_1x08_P2.54mm_Vertical
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
K1, K3: G5Q-1A; Relay_SPST_Omron-G5Q-1A
K2: G5Q-1; Relay_SPDT_Omron-G5Q-1
Q1, Q2, Q3: MTN2306AN3; TSOT-23
R1, R2, R3: 100k; R_0603_1608Metric
R4, R5, R12, R13: 10k; R_0805_2012Metric
R6: 15k; R_0603_1608Metric
R7: 120; R_0603_1608Metric
R8, R9, R10: 1M; R_0603_1608Metric
R11, R14: 3.3k; R_0603_1608Metric
U1: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U2: MCP2551-I-SN; SOIC-8_3.9x4.9mm_P1.27mm
Y1: CSTCE16M0V53-R0; CSTCE16M0V53R0; Manufacturer_Part_Number CSTCE16M0V53-R0; Mouser Part Number 81-CSTCE16M0V53-R0

Connections:
+3.3V: J7.4
+5V: C1.1, C5.1, J4.1, J5.1, J6.1, J7.5, J16.2, J17.2, K1.3, R5.1, R11.1, R14.1, U1.18 (VDD), U2.3 (VDD)
+12V: D2.1 (K), D3.1 (K), J2.1, J7.8, J15.2, K2.5, K3.5
/*2/INT_A: J11.6, U1.12 (~INT)
/*3: J11.5, Q2.1 (G), R9.1
/*4: J11.4, JP2.2 (B)
/*5: J11.3, JP1.2 (B)
/*6: J11.2, Q1.1 (G), R8.1
/*7: J11.1, J13.2
/*8: J10.10, K1.2, R4.1
/*9/CS_A: J10.9, U1.16 (~CS)
/*10: J10.8; also elsewhere on the board
/*11: J10.7, J17.1, R13.1
/*12: J10.6, J16.1, R12.1
/*13: J10.5, Q3.1 (G), R10.1
/A0: C2.1, J4.2, J8.1, R1.1
/A1: C3.1, J5.2, J8.2, R2.1
/A2: C4.1, J6.2, J8.3, R3.1
/A3: J8.4
/A4: J8.5
/A5: J8.6
/A6: J8.7
/A7: J8.8
/A8: J9.1
/A9: J9.2
/A10: J9.3
/A11: J9.4
/A12: J9.5
/A13: J9.6
/A14: J9.7
/A15: J9.8
/AIR+: J19.2, K2.3
/AIR-: J20.2, K3.3
/AREF: J10.3
/CANH: D1.1 (K), J21.1, R7.1, U2.7 (CANH)
/CANL: D1.2 (K), J21.2, R7.2, U2.6 (CANL)
/COIL1: D2.2 (A), K2.1, Q1.3 (D)
/COIL2: D3.2 (A), K3.1, Q2.3 (D)
/IOREF: J7.2
/MISO_A: J1.1, U1.15 (SO)
/MOSI_A: J1.4, U1.14 (SI)
/OSC1: U1.8 (OSC1), Y1.3 (OUTPUT)
/OSC2: U1.7 (OSC2), Y1.1 (INPUT)
/PRECHARGE: J18.2, K2.4
/RESET: J7.3
/RX0/0: J11.8
/RX1/19: J12.6
/RX2/17: J12.4
/RX3/15: J12.2
/RXCAN: JP1.1 (A), U1.2 (RXCAN), U2.4 (RXD)
/RtD_LED: J15.1, Q3.3 (D)
/SCK_A: J1.3, U1.13 (SCK)
/SCL/21: J10.1, J14.2, R11.2
/SDA/20: J10.2, J14.1, R14.2
/TX0/1: J11.7
/TX1/18: J12.5
/TX2/16: J12.3
/TX3/14: J12.1
/TXCAN: JP2.1 (A), U1.1 (TXCAN), U2.1 (TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.3 (A), D4.2 (A), J1.6, J2.2, J3.2, J4.3, J5.3, J6.3, J7.6, J7.7, J10.4, J13.1, J18.1, J19.1, J20.1, K1.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), R1.2, R2.2, R3.2, R4.2, R6.2, R8.2, R9.2, R10.2, R12.2, R13.2, U1.9 (VSS), U2.2 (VSS), Y1.2 (GND); also elsewhere on the board
unnamed: R5.2, U1.17 (~RESET)
unnamed: R6.1, U2.8 (Rs)
SHUTDOWN_CIRCUIT: D4.1 (K), J3.1, K1.5, K2.2, K3.2

Notes on the sheet:
Precharge
Power
Accel2
Ready to Drive SW
+5V
CAN
AIR+
Accel1
SDA/20
SCL/21
Shutdown SW
Sound
AIR-
* Indicates a PWM-capable pin
Brake
Ready to Drive LED
RESET
Shutdown Circuit

Board: 2 copper layers, 101.6 x 53.3 mm, 62 parts (3 on the bottom side), 38 nets.

Other parts of the board:
J22: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
MH1, MH2, MH3, MH4, MH5, MH6: MountingHole_3.2mm

Their connections:
/*10: J22.2; also elsewhere on the board
GND: J22.1; also elsewhere on the board

File ECUShield_MEGA_ver1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C5",0603,5,0.1u,
D1,SOT-23,1,NUP2105L,
"D2, D3, D4",D_DO-35_SOD27_P7.62mm_Horizontal,3,1S953,
J1,PinSocket_2x03_P2.54mm_Vertical,1,Conn_02x03_Odd_Even,
J10,PinSocket_1x10_P2.54mm_Vertical,1,PWM,
J11,PinSocket_1x08_P2.54mm_Vertical,1,PWM,
J12,PinSocket_1x08_P2.54mm_Vertical,1,Communication,
"J13, J14, J15, J16, J17, J18, J19, J2, J20, J21, J22, J3",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,12,Conn_01x02_Pin,
"J4, J5, J6",JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,3,Conn_01x03_Pin,
J7,PinSocket_1x08_P2.54mm_Vertical,1,Power,
"J8, J9",PinSocket_1x08_P2.54mm_Vertical,2,Analog,
"JP1, JP2",SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,2,SolderJumper_2_Open,
"K1, K3",Relay_SPST_Omron-G5Q-1A,2,G5Q-1A,
K2,Relay_SPDT_Omron-G5Q-1,1,G5Q-1,
"Q1, Q2, Q3",TSOT-23,3,MTN2306AN3,
"R1, R2, R3",0603,3,100k,
"R10, R8, R9",0603,3,1M,
"R11, R14",0603,2,3.3k,
"R12, R13, R4, R5",0805,4,10k,
R6,0603,1,15k,
R7,0603,1,120,
U1,SOIC-18W_7.5x11.6mm_P1.27mm,1,MCP2515-xSO,
U2,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2551-I-SN,
Y1,CSTCE16M0V53R0,1,CSTCE16M0V53-R0,

## KiCad design AMS_Temp_Iso_ver2/AMS_Temp_Iso_ver2.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C11, C12, C15: 0.1u; C_0603_1608Metric
C9, C10: 3.3u; CP_Radial_D5.0mm_P2.00mm
C13, C14: 1u; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
D3, D4: CUHS20S30; CUHS20S40H3F
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J13: Conn_01x10_Socket; PinSocket_1x10_P2.54mm_Vertical
J14, J15, J16, J17: Conn_01x04_Pin; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J18, J19: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
PS1: MCWI03-12S05; MCWI0312S15
R1, R2, R3, R4, R5, R6, R8, R9, R10, R11, R12, R13, R15: 10k; C_0805_2012Metric
R7, R14: Opt; R_0603_1608Metric
R16, R17, R18, R19: 3.3k; R_0603_1608Metric
U1, U2: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U3: ADuM1250; SOIC-8_3.9x4.9mm_P1.27mm
U4: NJM78L05SU3; SOT-89-3
Y1, Y2: CSTCE16M0V53-R0; CSTCE16M0V53R0; Manufacturer_Part_Number CSTCE16M0V53-R0; Mouser Part Number 81-CSTCE16M0V53-R0

Connections:
+5V: J13.3, J14.1, J18.2, J19.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R15.1
+5VA: C1.1, C2.1, C3.1, J19.1, R7.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC)
+5VD: C6.1, C7.1, C8.1, J18.1, R14.1, U2.4 (VCC), U2.6 (VCC), U2.18 (AVCC)
+5VL: C11.1, C14.1, D4.2 (A), R16.1, R17.1, U3.1 (VDD1), U4.1 (Vout)
+5VP: C10.1, C12.1, J17.4, PS1.6 (+Vout), R18.1, R19.1, U3.8 (VDD2)
+12V: C13.1, D3.2 (A), D4.1 (K), J15.1, J16.4, U4.3 (Vin)
/+Vin: C9.1, D3.1 (K), PS1.2 (+Vin)
/DTR: C15.2, J13.6
/SCL1: J15.3, J16.2, R17.2, U3.3 (SCL1)
/SCL2: J17.2, R19.2, U3.6 (SCL2)
/SDA1: J15.2, J16.3, R16.2, U3.2 (SDA1)
/SDA2: J17.3, R18.2, U3.7 (SDA2)
/Sens1: J1.1, R1.2, U1.23 (PC0)
/Sens2: J2.1, R2.2, U1.24 (PC1)
/Sens3: J3.1, R3.2, U1.25 (PC2)
/Sens4: J4.1, R4.2, U1.26 (PC3)
/Sens5: J5.1, R5.2, U1.19 (ADC6)
/Sens6: J6.1, R6.2, U1.22 (ADC7)
/Sens7: J7.1, R8.2, U2.23 (PC0)
/Sens8: J8.1, R9.2, U2.24 (PC1)
/Sens9: J9.1, R10.2, U2.25 (PC2)
/Sens10: J10.1, R11.2, U2.26 (PC3)
/Sens11: J11.1, R12.2, U2.19 (ADC6)
/Sens12: J12.1, R13.2, U2.22 (ADC7)
/XTAL1_A: U1.7 (XTAL1/PB6), Y1.3 (OUTPUT)
/XTAL1_D: U2.7 (XTAL1/PB6), Y2.3 (OUTPUT)
/XTAL2_A: U1.8 (XTAL2/PB7), Y1.1 (INPUT)
/XTAL2_D: U2.8 (XTAL2/PB7), Y2.1 (INPUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), D2.1 (K), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, J13.1, J13.2, J14.4, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.3 (GND), U2.5 (GND), U2.21 (GND), Y1.2 (GND), Y2.2 (GND)
GND1: C9.2, C11.2, C13.2, C14.2, J15.4, J16.1, PS1.1 (-Vin), PS1.3 (Remote_On/Off), U3.4 (GND1), U4.2 (GND)
GND2: C10.2, C12.2, J17.1, PS1.7 (-Vout), U3.5 (GND2)
MISO: J13.10, U1.16 (PB4), U2.16 (PB4)
MOSI: J13.9, U1.15 (PB3), U2.15 (PB3)
unnamed: D1.2 (A), R7.2
unnamed: D2.2 (A), R14.2
unnamed: C4.1, U1.20 (AREF)
unnamed: C5.1, U2.20 (AREF)
RESET: C15.1, J13.7, R15.2, U1.29 (~RESET/PC6), U2.29 (~RESET/PC6)
RXI: J13.4, U1.30 (PD0), U2.30 (PD0)
SCK: J13.8, U1.17 (PB5), U2.17 (PB5)
SCL: J14.3, U1.28 (PC5), U2.28 (PC5)
SDA: J14.2, U1.27 (PC4), U2.27 (PC4)
TXO: J13.5, U1.31 (PD1), U2.31 (PD1)

Notes on the sheet:
OUTPUT
上基板
ジャンパピンで短絡 書き込みのときは書き込むマイコン側のみ短絡
INPUT
下基板

Board: 2 copper layers, 85.0 x 117.5 mm, 64 parts (20 on the bottom side), 43 nets.

File AMS_Temp_Iso_ver2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_26, _25, _24, _23, _22, _21, _20, _19, _18, _17, _16, _15, _14, _13, _12, _11, _10, _9, _8, _7, _6, _5, _4, _3, _2, ",,26,,
"C1, C11, C12, C15, C2, C3, C4, C5, C6, C7, C8",0603,11,0.1u,
"C10, C9",CP_Radial_D5.0mm_P2.00mm,2,3.3u,
"C13, C14",0603,2,1u,
"D1, D2",0603,2,LED,
"D3, D4",CUHS20S40H3F,2,CUHS20S30,
"J1, J10, J11, J12, J2, J3, J4, J5, J6, J7, J8, J9",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,12,Conn_01x02_Pin,
J13,PinSocket_1x10_P2.54mm_Vertical,1,Conn_01x10_Socket,
"J14, J15, J16, J17",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,4,Conn_01x04_Pin,
"J18, J19",PinHeader_1x02_P2.54mm_Vertical,2,Conn_01x02_Pin,
PS1,MCWI0312S15,1,MCWI03-12S05,
"R1, R10, R11, R12, R13, R15, R2, R3, R4, R5, R6, R8, R9",0805,13,10k,
"R14, R7",0603,2,Opt,
"R16, R17, R18, R19",0603,4,3.3k,
"U1, U2",TQFP-32_7x7mm_P0.8mm,2,ATmega328P-A,
U3,SOIC-8_3.9x4.9mm_P1.27mm,1,ADuM1250,
U4,SOT-89-3,1,NJM78L05SU3,
"Y1, Y2",CSTCE16M0V53R0,2,CSTCE16M0V53-R0,

## KiCad design AMS_Temp_Master/AMS_Temp_Master.kicad_pcb

Parts:
C1, C3, C4, C5, C6, C7, C8, C9: 0.1u; C_0603_1608Metric
C2: 10u; C_0603_1608Metric
C10: 470u; CP_Elec_6.3x5.4_Nichicon
D1: UDZV5.1B; D_SOD-323_HandSoldering
D2: LED_R; LED_0603_1608Metric
D3: LED_G; LED_0603_1608Metric
D4: NUP2105L; SOT-23
D5: CUHS20S30; CUHS20S40H3F
J1: Conn_01x10_Socket; PinSocket_1x10_P2.54mm_Vertical
J2, J3, J5: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J4: Conn_01x04_Pin; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
Q1: AO3401A; SOT-23
R1, R2: 3.3k; R_0603_1608Metric
R3, R7, R9, R10: 10k; R_0603_1608Metric
R4, R5: Opt; R_0603_1608Metric
R6: 120; R_0603_1608Metric
R8: 15k; R_0603_1608Metric
U1: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U2: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U3: MCP2551-I-SN; SOIC-8_3.9x4.9mm_P1.27mm
U4: LD1117S50TR_SOT223; SOT-223-3_TabPin2
Y1, Y2: CSTCE16M0V53-R0; CSTCE16M0V53R0; Manufacturer_Part_Number CSTCE16M0V53-R0; Mouser Part Number 81-CSTCE16M0V53-R0

Connections:
+12V: C1.1, C10.1, D1.1 (K), D5.1 (K), J4.4, Q1.2 (S), U4.3 (VI)
/+12Vin: J5.1, Q1.3 (D)
/AMS_SIG: J2.2, R10.1, U1.1 (PD3)
/AREF: C6.1, U1.20 (AREF)
/CANH: D4.1 (K), J3.1, R6.1, U3.7 (CANH)
/CANL: D4.2 (K), J3.2, R6.2, U3.6 (CANL)
/CS: U1.13 (PB1), U2.16 (~CS)
/DTR: C9.2, J1.6
/INT: U1.32 (PD2), U2.12 (~INT)
/MISO: J1.10, U1.16 (PB4), U2.15 (SO)
/MOSI: J1.9, U1.15 (PB3), U2.14 (SI)
/RESET1: C9.1, J1.7, R3.2, U1.29 (~RESET/PC6)
/RESET2: R7.2, U2.17 (~RESET)
/RXCAN: U2.2 (RXCAN), U3.4 (RXD)
/RXI: J1.4, U1.30 (PD0)
/Rs: R8.1, U3.8 (Rs)
/SCK: J1.8, R5.1, U1.17 (PB5), U2.13 (SCK)
/SCL: J4.2, R2.2, U1.28 (PC5)
/SDA: J4.3, R1.2, U1.27 (PC4)
/TXCAN: U2.1 (TXCAN), U3.1 (TXD)
/TXO: J1.5, U1.31 (PD1)
/XTAL1: U1.7 (XTAL1/PB6), Y1.3 (OUTPUT)
/XTAL2: U1.8 (XTAL2/PB7), Y1.1 (INPUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, D2.1 (K), D3.1 (K), D4.3 (A), J1.1, J1.2, J2.1, J4.1, J5.2, R8.2, R9.2, R10.2, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.9 (VSS), U3.2 (VSS), U4.1 (GND), Y1.2 (GND), Y2.2 (GND)
unnamed: D1.2 (A), Q1.1 (G), R9.1
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: U2.8 (OSC1), Y2.3 (OUTPUT)
unnamed: U2.7 (OSC2), Y2.1 (INPUT)
VCC: C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, D5.2 (A), J1.3, R1.1, R2.1, R3.1, R4.1, R7.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.18 (VDD), U3.3 (VDD), U4.2 (VO)

Notes on the sheet:
OUTPUT
INPUT

Board: 2 copper layers, 80.0 x 50.0 mm, 37 parts (0 on the bottom side), 30 nets.

File AMS_Temp_Master/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C3, C4, C5, C6, C7, C8, C9",0603,8,0.1u,
C10,CP_Elec_6.3x5.4_Nichicon,1,470u,
C2,0603,1,10u,
D1,D_SOD-323_HandSoldering,1,UDZV5.1B,
D2,0603,1,LED_R,
D3,0603,1,LED_G,
D4,SOT-23,1,NUP2105L,
D5,CUHS20S40H3F,1,CUHS20S30,
J1,PinSocket_1x10_P2.54mm_Vertical,1,Conn_01x10_Socket,
"J2, J3, J5",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,3,Conn_01x02_Pin,
J4,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,1,Conn_01x04_Pin,
Q1,SOT-23,1,AO3401A,
"R1, R2",0603,2,3.3k,
"R10, R3, R7, R9",0805,4,10k,
"R4, R5",0603,2,Opt,
R6,0603,1,120,
R8,0603,1,15k,
U1,TQFP-32_7x7mm_P0.8mm,1,ATmega328P-A,
U2,SOIC-18W_7.5x11.6mm_P1.27mm,1,MCP2515-xSO,
U3,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2551-I-SN,
U4,SOT-223-3_TabPin2,1,LD1117S50TR_SOT223,
"Y1, Y2",CSTCE16M0V53R0,2,CSTCE16M0V53-R0,
